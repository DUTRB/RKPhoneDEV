## 驱动代码/kernel/ec20_power/Kconfig
```kconfig
config EC20_POWER
        tristate "EC20 POWER"
	depends on GPIOLIB
	default n
	help
	  Say Y here if you have EC20 module.
	  If unsure, say N.
```
